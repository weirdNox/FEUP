2016/17 - 1

l1     In     1      52.0005e-006
c2     1      0      1.0372e-009
l3     1      Out    53.4307e-006
c4     Out    0      460.1761e-012
rc     Out    0      250

vin    In     0      AC
.ac    OCT    1000   100k   2Meg
